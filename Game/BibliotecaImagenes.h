#ifndef BIBLIOTECA_IMAGENES_H
#define BIBLIOTECA_IMAGENES_H

#include <U8g2lib.h>

int velocidadTexto =2;
extern unsigned long inicioTe;
//Arrays con la imformacion de las imegenes de los iconos
static const unsigned char IconoAjustes_bits[] U8X8_PROGMEM = {0x40,0x04,0x00,0x60,0x0c,0x00,0x60,0x0c,0x00,0xe0,0x0e,0x00,0xc0,0x06,0x00,0x80,0x03,0x00,0x80,0x03,0x00,0x80,0x03,0x00,0x80,0x03,0x00,0x80,0x03,0x00,0x80,0x03,0x00,0x80,0x03,0x00,0x80,0x03,0x00,0x80,0x03,0x00,0x80,0x03,0x00,0x80,0x02,0x00,0x80,0x03,0x00};
static const unsigned char IconoBanar_bits[] U8X8_PROGMEM = {0x00,0x04,0x00,0x80,0x0a,0x00,0x40,0x05,0x00,0x80,0x08,0x00,0x00,0x14,0x00,0x20,0x09,0x00,0xd0,0x02,0x00,0xff,0xff,0x01,0xff,0xff,0x01,0xfe,0xff,0x00,0xfe,0xff,0x00,0xfe,0xff,0x00,0xfc,0x7f,0x00,0xf8,0x3f,0x00,0xf0,0x1f,0x00,0x18,0x30,0x00,0x00,0x00,0x00};
static const unsigned char IconoComida_bits[] U8X8_PROGMEM = {0x54,0x04,0x00,0x54,0x0c,0x00,0x54,0x1c,0x00,0x54,0x1c,0x00,0x7c,0x1c,0x00,0x7c,0x1c,0x00,0x7c,0x1c,0x00,0x38,0x1c,0x00,0x10,0x0c,0x00,0x10,0x04,0x00,0x10,0x04,0x00,0x10,0x04,0x00,0x10,0x04,0x00,0x10,0x04,0x00,0x10,0x04,0x00,0x28,0x0a,0x00,0x10,0x04,0x00};
static const unsigned char IconoDormir_bits[] U8X8_PROGMEM = {0xc0,0x01,0x00,0xf8,0x07,0x00,0xfc,0x07,0x00,0xfe,0x0f,0x00,0xfe,0x0f,0x00,0xff,0x8c,0x00,0x7f,0x40,0x01,0x3f,0x80,0x00,0x1f,0x00,0x00,0x1f,0x00,0x00,0x3f,0x00,0x00,0x7f,0x18,0x00,0xff,0x1c,0x00,0xfe,0x1f,0x00,0xfe,0x0f,0x00,0xfc,0x07,0x00,0xf0,0x03,0x00};
static const unsigned char IconoJugar_bits[] U8X8_PROGMEM = {0x00,0x0a,0x00,0x00,0x05,0x00,0x00,0x05,0x00,0x00,0x0a,0x00,0x02,0x00,0x00,0xfd,0xff,0x01,0xf2,0xff,0x01,0xf2,0xff,0x01,0xf2,0xff,0x01,0xf2,0xff,0x01,0xfc,0xff,0x01,0xe0,0xff,0x00,0xc0,0x7f,0x00,0x80,0x3f,0x00,0xf0,0xff,0x01,0x00,0x00,0x00,0x00,0x00,0x00};

static const unsigned char image_bocaIde_bits[] U8X8_PROGMEM = {0x02,0x02,0x05};
static const unsigned char image_brazos_bits[] U8X8_PROGMEM = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x03,0x00,0x00,0x00,0x00,0x03,0x06,0x00,0x00,0x00,0x80,0x01,0x38,0x00,0x00,0x00,0xc0,0x00,0x60,0x00,0x00,0x00,0x60,0x00,0x40,0x00,0x00,0x00,0x60,0x00,0x60,0x00,0x00,0x00,0xa0,0x00,0x50,0x00,0x00,0x00,0x20,0x01,0x48,0x00,0x00,0x00,0xe0,0x00,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};
static const unsigned char image_corazonI_bits[] U8X8_PROGMEM = {0x00,0x66,0xff,0xff,0x7e,0x3c,0x18,0x00};
static const unsigned char image_cuerpo_bits[] U8X8_PROGMEM = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xa8,0x00,0x00,0x00,0x00,0x00,0xac,0x01,0x00,0x00,0x00,0x00,0x2c,0x01,0x00,0x00,0x00,0x00,0x24,0x03,0x00,0x00,0x00,0x00,0xa6,0x02,0x00,0x00,0x00,0x00,0x22,0x06,0x00,0x00,0x00,0x00,0x22,0x04,0x00,0x00,0x00,0x00,0x23,0x0c,0x00,0x00,0x00,0x00,0xa1,0x08,0x00,0x00,0x00,0x00,0x21,0x08,0x00,0x00,0x00,0x00,0x23,0x0e,0x00,0x00,0x00,0x00,0xfc,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};
static const unsigned char image_dormir_bits[] U8X8_PROGMEM = {0x00,0x47,0x00,0x00,0x00,0xc0,0x7d,0x00,0x00,0x00,0x40,0xe0,0x00,0x00,0x00,0x20,0x20,0x00,0x00,0x00,0x20,0x20,0x00,0x00,0x00,0x30,0x30,0x00,0x00,0x00,0x10,0x1c,0x00,0x00,0x00,0x10,0x02,0x00,0x00,0x00,0x10,0x02,0x00,0x00,0x00,0x10,0x03,0x00,0x00,0x00,0x30,0x1f,0x00,0x00,0x00,0xa2,0x71,0x00,0x00,0x08,0xe3,0xc0,0x00,0x7c,0x00,0x63,0x80,0x81,0xc7,0x0c,0x63,0x00,0xff,0x80,0x0d,0x3f,0x00,0x31,0x00,0x0e,0x67,0x80,0x10,0x00,0x0c,0x47,0x80,0x10,0x00,0x0c,0xcf,0x81,0x10,0x00,0x0c,0x0b,0x87,0x10,0x00,0x0c,0x1b,0xfc,0x10,0x00,0x0c,0x13,0x70,0x10,0x00,0x0c,0xff,0xff,0xff,0xff,0x0f,0xff,0xff,0xff,0xff,0x0f,0xff,0xff,0xff,0xff,0x0f,0xff,0xff,0xff,0xff,0x0f,0xff,0xff,0xff,0xff,0x0f,0xff,0xff,0xff,0xff,0x0f,0xff,0xff,0xff,0xff,0x0f};
static const unsigned char image_gorroDucha_bits[] U8X8_PROGMEM = {0x00,0xfe,0x3f,0x00,0x01,0x03,0x60,0x00,0x80,0x00,0x80,0x01,0x40,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x10,0x00,0x00,0x10,0x2c,0x00,0x00,0xec,0x03,0x00,0x00,0x40,0x02,0x00,0x00,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x00,0x40,0x00,0x00,0x00,0x40,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x30,0x00,0x00,0x1c};
static const unsigned char image_llantoD_bits[] U8X8_PROGMEM = {0x00,0x07,0x80,0x07,0xb1,0x07,0xb0,0x07,0x00,0x03};
static const unsigned char image_llantoI_bits[] U8X8_PROGMEM = {0x07,0x00,0x0f,0x00,0x6f,0x04,0x6f,0x00,0x06,0x00};
static const unsigned char image_manoD_bits[] U8X8_PROGMEM = {0x0f,0x09,0x19,0x11,0x11,0x13,0x1e};
static const unsigned char image_manoI_bits[] U8X8_PROGMEM = {0x1e,0x12,0x13,0x11,0x11,0x19,0x0f};
static const unsigned char image_OjoMareo_bits[] U8X8_PROGMEM = {0x0a,0x20,0x0d,0x24,0x1d};
static const unsigned char image_OrejaD_bits[] U8X8_PROGMEM = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x00,0x00,0x00,0x00,0x00,0xfe,0x01,0x00,0x00,0x00,0x00,0x03,0x0f,0x00,0x00,0x00,0x00,0x03,0x18,0x00,0x00,0x00,0x00,0x06,0x20,0x00,0x00,0x00,0x00,0xc4,0x21,0x00,0x00,0x00,0x00,0xc4,0x43,0x00,0x00,0x00,0x00,0xcc,0xc7,0x00,0x00,0x00,0x00,0x88,0x8f,0x00,0x00,0x00,0x00,0x08,0x8f,0x01,0x00,0x00,0x00,0x18,0x1e,0x01,0x00,0x00,0x00,0x10,0x1c,0x01,0x00,0x00,0x00,0x60,0x00,0x01,0x00,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0x00,0x00,0x00,0x00,0x00,0x1c,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};
static const unsigned char image_OrejaI_bits[] U8X8_PROGMEM = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x00,0x00,0x00,0x00,0xf0,0x0f,0x00,0x00,0x00,0x00,0x1e,0x18,0x00,0x00,0x00,0x00,0x03,0x18,0x00,0x00,0x00,0x80,0x00,0x0c,0x00,0x00,0x00,0x80,0x70,0x04,0x00,0x00,0x00,0x40,0x78,0x04,0x00,0x00,0x00,0x60,0x7c,0x06,0x00,0x00,0x00,0x20,0x3e,0x02,0x00,0x00,0x00,0x30,0x1e,0x02,0x00,0x00,0x00,0x10,0x0f,0x03,0x00,0x00,0x00,0x10,0x07,0x01,0x00,0x00,0x00,0x10,0xc0,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x1c,0x00,0x00,0x00,0x00,0x00,0x07,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00};
static const unsigned char image_particulasComidaI_bits[] U8X8_PROGMEM = {0x20,0x00,0x08,0x19,0x10};
static const unsigned char image_particulasComidaID_bits[] U8X8_PROGMEM = {0x01,0x00,0x04,0x26,0x02};
static const unsigned char image_particulasSucio_bits[] U8X8_PROGMEM = {0x00,0x07,0x00,0x01,0x00,0x01,0x00,0x01,0xf0,0x01,0x10,0x00,0x10,0x00,0x30,0x00,0x20,0x00,0x20,0x00,0x1f,0x00,0x01,0x00};
static const unsigned char image_zanahoria_bits[] U8X8_PROGMEM = {0xfc,0x00,0xfc,0x00,0xfe,0x01,0xfd,0x03,0x81,0x03,0xf3,0x03,0xfa,0x01,0xfe,0x01,0xfe,0x01,0x3c,0x01,0x04,0x01,0xf4,0x00,0xf8,0x00,0xe8,0x00,0x68,0x00,0x58,0x00,0x70,0x00};
static const unsigned char image_Zdormir_bits[] U8X8_PROGMEM = {0xff,0x00,0xc1,0x00,0x61,0x00,0x21,0x00,0x3c,0x00,0x78,0x00,0x0c,0x00,0x04,0x01,0x06,0x01,0xfe,0x01};
static const unsigned char image_ojosCerrados_bits[] U8X8_PROGMEM = {0x01,0x01};
static const unsigned char tazaTe_bits[] U8X8_PROGMEM = {0x02,0x00,0x00,0xfd,0xff,0x01,0xf2,0xff,0x01,0xf2,0xff,0x01,0xf2,0xff,0x01,0xf2,0xff,0x01,0xfc,0xff,0x01,0xe0,0xff,0x00,0xc0,0x7f,0x00,0x80,0x3f,0x00,0xf0,0xff,0x01,0x00,0x00,0x00,0x00,0x00,0x00};

// Metodo parda poner la pisicion y dibujar las imagenenes en pantalla
void dibujarIconos(U8G2 &u8g2, int seleccion) {

    // IconoComida_v03
    u8g2.drawXBMP(37, 46, 17, 17, IconoComida_bits);

    // IconoJugar_v01
    u8g2.drawXBMP(18, 47, 17, 17, IconoJugar_bits);

    // IconoBanar_v03e
    u8g2.drawXBMP(75, 46, 17, 17, IconoBanar_bits);

    // IconoDormirv01
    u8g2.drawXBMP(55, 46, 17, 17, IconoDormir_bits);

    // IconoAjustes_v01
    u8g2.drawXBMP(92, 46, 17, 17, IconoAjustes_bits);
    
    // Triangulo
    int posicionX[]= {26/*jugar*/, 40/*comida*/, 60/*Dormir*/ ,80/*Banar*/, 97/*Ajustes*/};
    int x = posicionX [seleccion];
    int y = 36;
    int ancho = 7;
    int alto = 5;
    u8g2.drawTriangle(   x, y, x + ancho, y, x + ancho/2, y + alto );

}
void dibujoAjustesUI(U8G2 &u8g2, int seleccionAjustes, int adjHora, int adjMin, int adjSeg) {
    u8g2.setFont(u8g2_font_4x6_tf);
    
    // Titulo Texto / Velocidad
    u8g2.drawStr(5, 10, "VELOCIDAD ANIMACION");
    
    // Botones Velocidad
    if (seleccionAjustes == 0) u8g2.drawFrame(4, 15, 30, 10);
    u8g2.drawStr(8, 22, "Lento");
    
    if (seleccionAjustes == 1) u8g2.drawFrame(39, 15, 30, 10);
    u8g2.drawStr(43, 22, "Medio");
    
    if (seleccionAjustes == 2) u8g2.drawFrame(74, 15, 30, 10);
    u8g2.drawStr(78, 22, "Fast");

    // Seccion Reloj
    u8g2.drawStr(5, 40, "AJUSTE RELOJ");
    
    char buf[10];
    // Boton Hora
    if (seleccionAjustes == 3) u8g2.drawBox(4, 45, 25, 10);
    u8g2.setDrawColor(seleccionAjustes == 3 ? 0 : 1);
    sprintf(buf, "%02dh", adjHora);
    u8g2.drawStr(8, 52, buf);
    u8g2.setDrawColor(1);

    // Boton Minuto
    if (seleccionAjustes == 4) u8g2.drawBox(34, 45, 25, 10);
    u8g2.setDrawColor(seleccionAjustes == 4 ? 0 : 1);
    sprintf(buf, "%02dm", adjMin);
    u8g2.drawStr(38, 52, buf);
    u8g2.setDrawColor(1);

    // Boton Segundo
    if (seleccionAjustes == 5) u8g2.drawBox(64, 45, 25, 10);
    u8g2.setDrawColor(seleccionAjustes == 5 ? 0 : 1);
    sprintf(buf, "%02ds", adjSeg);
    u8g2.drawStr(68, 52, buf);
    u8g2.setDrawColor(1);

    // Boton Aceptar
    if (seleccionAjustes == 6) u8g2.drawFrame(95, 52, 32, 11);
    u8g2.drawStr(98, 60, "ACEPTAR");
}

void dibujoIDE(U8G2 &u8g2)
{
      static float tiempo = 0;
    tiempo += 0.3;

    // movimiento vertical suave
    float offsetY = sin(tiempo) * 2;
   
    float cx = 66;
    float cy = 37;

    // cabeza
    u8g2.drawEllipse(66, 37 + offsetY, 9, 9);

    // orejas
    u8g2.drawXBMP(43, 9 + offsetY, 45, 45, image_OrejaI_bits);
    u8g2.drawXBMP(45, 9 + offsetY, 45, 45, image_OrejaD_bits);

    // cuerpo
    u8g2.drawXBMP(45, 17 + offsetY, 45, 45, image_cuerpo_bits);



     // bocaIde
    u8g2.drawXBMP(65, 37+ offsetY, 3, 3, image_bocaIde_bits);


     // brazos
    u8g2.drawXBMP(45, 16  + offsetY, 45, 45, image_brazos_bits);

 


     float baseY = 59 + offsetY;
    u8g2.drawLine(68, baseY, 68, 59);
    u8g2.drawLine(64, baseY, 64, 59);

  bool parpadeo = false;
 if( sin ( tiempo *1)> 0.95){
   parpadeo  = true;
 }
 if(parpadeo){
    // ojosCerrados
    u8g2.drawXBMP(62, 37 + offsetY, 9, 1 + offsetY, image_ojosCerrados_bits);
 }
else{

         // ojo derecho
  u8g2.drawLine(70, 33 + offsetY, 70, 37 + offsetY);
  // ojo izquierdo
   u8g2.drawLine(62, 33 + offsetY, 62, 37 + offsetY); 
    }

}

void dibujoSucio(U8G2 &u8g2){
 // dibujoIDE(u8g2);
  const int numParticulas = 2;
  static int x[numParticulas];
  static int y[numParticulas];
  static bool inicio = false;

  unsigned long tiempo = millis();
  int particulasActuales = 0;

  
  const int cuerpoX1 = 50;
  const int cuerpoX2 = 85;
  const int cuerpoY1 = 25;
  const int cuerpoY2 = 64;

  if(!inicio){
    for(int i = 0; i < numParticulas; i++){
      x[i] = random(60, 72);   // más centrado en boca/cabeza
      y[i] = random(35, 45);
    }
    inicio = true;
  }

  while(particulasActuales < numParticulas){

    int i = particulasActuales;

  
    y[i] -= 1.2;

    
    if (y[i] > 35) {
      x[i] += sin((tiempo + i * 200) / 400.0) * 0.3;
    } else {
      x[i] += sin((tiempo + i * 100) / 200.0) * 1.5;
    }

 
    bool dentroCuerpo =
      (x[i] > cuerpoX1 && x[i] < cuerpoX2 &&
       y[i] > cuerpoY1 && y[i] < cuerpoY2);

    if (dentroCuerpo) {

   
      if (y[i] > 40) {
        y[i] = cuerpoY1 - 2; // sale por cuello/cabeza
      } 
      else {
        // empuje lateral suave
        if (x[i] < 66) x[i] = cuerpoX1 - 2;
        else x[i] = cuerpoX2 + 2;
      }
    }

   
    if (y[i] < 5){
      x[i] = random(60, 72);
      y[i] = random(35, 45);
    }

    u8g2.drawXBMP(x[i], y[i], 11, 12, image_particulasSucio_bits);

    particulasActuales++;
  }
}
void dibujarBano(U8G2 &u8g2){

  unsigned long tiempo = millis();
     // Cabeza
    u8g2.drawEllipse(66, 37, 9, 9);
    
    // OrejaI
    u8g2.drawXBMP(43, 9, 45, 45, image_OrejaI_bits);

    // OrejaD
    u8g2.drawXBMP(45, 9, 45, 45, image_OrejaD_bits);

    // gorroDucha
    u8g2.drawXBMP(51, 17, 31, 20, image_gorroDucha_bits);
    
    // ojosCerrados
    u8g2.drawXBMP(62, 37, 9, 1, image_ojosCerrados_bits);

    // IconoBanar_v03e
    u8g2.drawXBMP(59, 40, 17, 17, IconoBanar_bits);
     
     int maxBurbojas = 8;
     for ( int i = 0; i< maxBurbojas;  i++){

     float offsetTiempo = ( tiempo + i *200) % 3000;

     int y = 50 - (offsetTiempo /3500.0)*70;
     
     int separacion = (50 - y) /2 ; 

     
     int aleatorio = random(-5, 5);
     int x = 59+ ((i % 3) - 1) *(4 + separacion + aleatorio);
      if (y < 12) {

        int pop = (tiempo / 50 + i) % 3;  

        if (pop == 0) {
            u8g2.drawPixel(x, y);
        } 
        else if (pop == 1) {
            u8g2.drawCircle(x, y, 2);
        } 
        else {
            u8g2.drawCircle(x, y, 3);
        }

    } else {
      
        // burbijaBaño
        u8g2.drawEllipse(x, y, 2, 2);
    }
      
     }
   

}

void dibujarHambre(U8G2 &u8g2){

      static float tiempo = 0;
     tiempo += 0.1;

    // movimiento vertical suave
    float offsetY = sin(tiempo) * 2;
    float offsetX = cos(tiempo* 2 ) *2; 
    float ojosOffsetY = sin(tiempo) * 2 + sin(tiempo* 4 ) *1; ;

    // cabeza
    u8g2.drawEllipse(66  , 37 + offsetY, 9, 9);

    // orejas
    u8g2.drawXBMP(43  , 9 + offsetY, 45, 45, image_OrejaI_bits);
    u8g2.drawXBMP(45   , 9 + offsetY, 45, 45, image_OrejaD_bits);

    // cuerpo
    u8g2.drawXBMP(45 , 17 + offsetY, 45, 45, image_cuerpo_bits);



     // bocaIde
    u8g2.drawXBMP(65 , 37+ offsetY, 3, 3, image_bocaIde_bits);


     // brazos
    u8g2.drawXBMP(45  , 16  + offsetY, 45, 45, image_brazos_bits);

 
     float baseY = 59 + offsetY;
    u8g2.drawLine(68  , baseY, 68, 59);
    u8g2.drawLine(64  , baseY, 64, 59);
  
  // OjoMareo
  u8g2.drawXBMP(67 + ojosOffsetY , 34 + offsetY, 6, 5, image_OjoMareo_bits);
  // OjoMareo
  u8g2.drawXBMP(60 + ojosOffsetY  , 34 - offsetY, 6, 5, image_OjoMareo_bits);

}
void dibujarComer(U8G2 &u8g2){

  unsigned long tiempo = millis();
    // Cabeza
    u8g2.drawEllipse(66, 37, 9, 9);
    
    // OrejaI
    u8g2.drawXBMP(43, 9, 45, 45, image_OrejaI_bits);

    // OrejaD
    u8g2.drawXBMP(45, 9, 45, 45, image_OrejaD_bits);
    
    // ojosCerrados
    u8g2.drawXBMP(62, 37, 9, 1, image_ojosCerrados_bits);

    // bocaIde
    u8g2.drawXBMP(65, 39, 3, 3, image_bocaIde_bits);
    

    // manoI
    u8g2.drawXBMP(58, 47, 5, 7, image_manoI_bits);
    // manoD
    u8g2.drawXBMP(69, 46, 5, 7, image_manoD_bits);
    // zanahoria
    u8g2.drawXBMP(61, 42 , 10, 17, image_zanahoria_bits);

     bool aparecer = (tiempo %600) <300;
    
    if (aparecer ){
     // particulasComidaID
     u8g2.drawXBMP(76, 42, 6, 5, image_particulasComidaID_bits);
     // particulasComidaI
     u8g2.drawXBMP(49, 42, 6, 5, image_particulasComidaI_bits);
    }
   

}
void dibujarSueno(U8G2 &u8g2){
  // dibujoIDE(u8g2);
  //Tiempo
   unsigned  long tiempo = millis();

  float factor = (sin(tiempo / 1000.0)*PI); 
   
   //Offsets maximos
   int offsetZ= factor *0.5;
   
  //Offsets maximos
   int ZOffset = offsetZ *factor;
   
  // Zdormido
  u8g2.setFont(u8g2_font_4x6_tr);
    u8g2.drawStr(109 +ZOffset, 19 +ZOffset, "z");
    u8g2.drawStr(99 +ZOffset, 28 +ZOffset, "z");
    u8g2.drawStr(92 +ZOffset, 36 +ZOffset, "z");

}
void dibujarDormir(U8G2 &u8g2){
  //Tiempo
   unsigned  long tiempo = millis();

     // dormir
    u8g2.drawXBMP(48, 19, 36, 29, image_dormir_bits);

  float factor = (sin(tiempo / 1000.0)*PI); 
   
   //Offsets maximos
   int offsetZ= factor *0.5;
   
  //Offsets maximos
   int ZOffset = offsetZ *factor;
   
   // Zdormir
    u8g2.drawXBMP(65 + ZOffset, 10+ ZOffset , 9 , 10 , image_Zdormir_bits);
}
void dibujarTe(U8G2 &u8g2){
   //Tiempo
   unsigned  long tiempo = millis();
   float factor = (sin(tiempo / 1000.0)*PI); 
   //Offsets maximos
   int offsetBoca = factor *0.5;
   int offsetOjo = factor *0.5;
  //Offsets maximos
   int bocaOffset = offsetBoca *factor;
   int ojoOffset = offsetOjo  *factor;

    // Cabeza
    u8g2.drawEllipse(66, 29, 9, 9);

    // OrejaI
    u8g2.drawXBMP(43, 1, 45, 45, image_OrejaI_bits);

    // OrejaD
    u8g2.drawXBMP(45, 1, 45, 45, image_OrejaD_bits);

    // bocaIde
    u8g2.drawXBMP(65, 28 + bocaOffset , 3, 3, image_bocaIde_bits);

    // ojoD
    u8g2.drawLine(70, 24 + ojoOffset , 70, 27);

    // OjoI
    u8g2.drawLine(62, 24 + ojoOffset , 62, 27);

    
    
    // manoD
    u8g2.drawXBMP(74, 36, 5, 7, image_manoD_bits);

    // manoI
    u8g2.drawXBMP(55, 36, 5, 7, image_manoI_bits);
   
    //TazaTe
    u8g2.drawXBMP(57, 32, 17, 13, tazaTe_bits);
    
}
void dibujarFeliz(U8G2 &u8g2){
    

  static float tiempo = 0;
  static float posicionX =0;
  static float posicionY =0;
  static float velocidadX = 6; 


    tiempo += 2;
     posicionX += velocidadX ;
     
    if (posicionX >= 128 - 75){   
     posicionX = 128 - 75;
     velocidadX *= -1; 
  }

  if (posicionX <= -43){
    posicionX = -43;
    velocidadX *= -1; 
  }
    
    float offsetY = sin(tiempo) *-6;
   
    

    // cabeza
    u8g2.drawEllipse(posicionX +66, 37 + offsetY, 9, 9);

    // orejas
    u8g2.drawXBMP(posicionX  + 43, 9 + offsetY, 45, 45, image_OrejaI_bits);
    u8g2.drawXBMP(posicionX + 45, 9 + offsetY, 45, 45, image_OrejaD_bits);

    // cuerpo
    u8g2.drawXBMP(posicionX  + 45, 17 + offsetY, 45, 45, image_cuerpo_bits);



     // bocaIde
    u8g2.drawXBMP(posicionX + 65, 37+ offsetY, 3, 3, image_bocaIde_bits);


     // brazos
    u8g2.drawXBMP(posicionX + 45, 16  + offsetY, 45, 45, image_brazos_bits);

 


     float baseY = 59 + offsetY;
    u8g2.drawLine(posicionX  + 68, baseY, posicionX + 68, baseY);
    u8g2.drawLine(posicionX + 64, baseY, posicionX + 64,baseY);

    

    // corezonD
    u8g2.drawXBMP(posicionX + 67, 33+ offsetY, 8, 8 , image_corazonI_bits);

     // corazonI
    u8g2.drawXBMP(posicionX + 59, 33 + offsetY, 8, 8 , image_corazonI_bits);

}
void dibujarMuerte(U8G2 &u8g2){
 
  static float tiempo = 0;
    tiempo += 0.08;

    // movimiento vertical suave
    float offsetY = sin(tiempo) * 2;
    float tearFactor = sin(tiempo) * 1;
    
    float cx = 66;
    float cy = 37;

    // cabeza
    u8g2.drawEllipse(66, 37 + offsetY, 9, 9);

    // orejas
    u8g2.drawXBMP(43, 9 + offsetY, 45, 45, image_OrejaI_bits);
    u8g2.drawXBMP(45, 9 + offsetY, 45, 45, image_OrejaD_bits);

    // cuerpo
    u8g2.drawXBMP(45, 17 + offsetY, 45, 45, image_cuerpo_bits);

        // ojosCerrados
    u8g2.drawXBMP(62, 37 + offsetY, 9, 1, image_ojosCerrados_bits);

     // bocaIde
    u8g2.drawXBMP(65, 39 + offsetY, 3, 3, image_bocaIde_bits);


    // manoD
    u8g2.drawXBMP(69, 39, 5, 7, image_manoD_bits);

    // manoI
    u8g2.drawXBMP(60, 39, 5, 7, image_manoI_bits);



     float baseY = 59 + offsetY;
    u8g2.drawLine(68, baseY, 68,59);
    u8g2.drawLine(64, baseY, 64, 59 );
    
    float tearXOffset = tearFactor * 2;
    u8g2.drawXBMP(79 - tearXOffset, 34 + offsetY, 11, 5, image_llantoD_bits);
    u8g2.drawXBMP(45 + tearXOffset, 34 + offsetY, 11, 5, image_llantoI_bits);
  

}
//Frases
const char* obtenerFrase(int indice) {
    static const char* frases[] = {
        "¡Dios Mio! ¡Voy a llegar tarde!",
        "¿De que sirve un libro sin dibujos?",
        "¡Valganme mis orejas y bigotes!",
        "¡Me gustaria encogerme!",
        "¡Acabas con la paciencia de una ostra!",
        "¡La Duquesa! ¡Me hara ejecutar!",
        "Llegaras si caminas lo suficiente.",
        "Veo lo que como o como lo que veo.",
        "No hables de matar al Tiempo.",
        "Siempre es la hora del te",
        "¡Chiton! ¡Chiton!"
    };

    if (indice < 0 || indice > 10) indice = 0;

    return frases[indice];
}
   

void frasesAliacia(U8G2 &u8g2, int indiceFraseAleatoria, int xPos) {
    u8g2.setFont(u8g2_font_5x7_tr);
    u8g2.drawStr(xPos, 63, obtenerFrase(indiceFraseAleatoria));
}
#endif
